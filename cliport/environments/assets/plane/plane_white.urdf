Commit message: debug refer, generate OOPP data

File: cliport/environments/assets/plane/plane_white.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=200 200 10; visual mesh filename=plane100.obj scale=1 1 1
